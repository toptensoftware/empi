IMAGE_INSTALL:append = " \
    alsa-utils \
    alsa-lib \
"
